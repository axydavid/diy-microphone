# Repository axydavid/diy-microphone

## KiCad design mic_pcb.kicad_pcb

Board: 2 copper layers, 36.5 x 63.0 mm, 22 parts (0 on the bottom side), 16 nets.

Parts:
C1, C2, C3: 22uf 35v; C_Radial_D8.0mm_H11.5mm_P3.50mm
C4, C5, C6, C7: 2200uf 16v; CP_Radial_D12.5mm_P5.00mm
J1: MIC_IN; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2: GAIN; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J3: AUDIO_OUT; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4: 5v USB; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
Q1: 2N4416; TO127P584H533-4
R1, R2, R5, R6: 2.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R3, R4: 3.9k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R7, R8: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
U1: THAT1512; DIP-8_W7.62mm_Socket
U2: NMA0515SC; Converter_DCDC_Murata_NMAxxxxSC_THT

Connections:
GNDREF: C4.2, C5.1, J1.1, J3.1, R3.1, R4.1, R5.2, R6.2, U1.5 (REF), U2.5 (0V)
unnamed: C1.1, R4.2, U1.3 (IN+)
unnamed: C1.2, Q1.1, R2.2
unnamed: C2.1, R3.2, U1.2 (IN-)
unnamed: C2.2, Q1.2, R1.2
unnamed: C3.1, J3.2
unnamed: C3.2, U1.6
unnamed: C4.1, R1.1, R6.1, R7.2, U1.7 (V+)
unnamed: C5.2, R2.1, R5.1, R8.2, U1.4 (V-)
unnamed: C6.1, C7.1, J4.2, U2.1 (VIN+)
unnamed: C6.2, C7.2, J4.1, U2.2 (VIN-)
unnamed: J1.2, Q1.3
unnamed: J2.1, U1.1 (RG1)
unnamed: J2.2, U1.8 (RG2)
unnamed: R7.1, U2.6 (VOUT+)
unnamed: R8.1, U2.4 (VOUT-)

## Commit log

2023-02-21 Add files via upload
    updated design
